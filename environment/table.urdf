Commit message: solid red can

File: environment/table.urdf (robot description, URDF)
Before this commit: robot station.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision mesh filename=tabletop1.obj scale=1.2 1 1; visual mesh filename=tabletop1.obj scale=1.2 1 1
